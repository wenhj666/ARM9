# Keil uVision project gpio_led.uvproj, settings and files
target gpio_led (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: gpio_led +hex
  AfterMake: D:\Keil_ARM\ARM\ARMCC\bin\fromelf.exe --bin --output=./bin/@p.bin ./Objects/@p.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\startcode;.\source
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x31000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group source
    ./source/: main.c led.c key.c
  group startcode
    ./startcode/: 2440addr.h 2440addr.inc 2440init.s 2440slib.s def.h Memcfg.inc mmu.c mmu.h nand.c nand.h option.h option.inc
